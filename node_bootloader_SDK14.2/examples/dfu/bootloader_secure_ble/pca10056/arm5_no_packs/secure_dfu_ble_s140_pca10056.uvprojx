# Keil uVision project secure_dfu_ble_s140_pca10056.uvprojx, settings and files
target nrf52840_xxaa_s140 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa_s140 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_WIZBLE52840 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0 ETH_GATEWAY
  c misc: --reduce_paths
  c include: ..\..\config;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common;..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\components\toolchain;..\..;..\..\..\dfu_req_handling;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\config;..\..\..\..\..\external\wiznet\ioLibrary_Driver\Application\loopback;..\..\..\..\..\external\wiznet\ioLibrary_Driver\Ethernet\W5500;..\..\..\..\..\external\wiznet\ioLibrary_Driver\Ethernet;..\..\..\..\..\external\wiznet;..\..\..\..\..\external\wiznet\ioLibrary_Driver\Internet\tftp;..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\external\fprintf;..\..\..\..\..\external\segger_rtt
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=5,-DS140,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: ..\..\config;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw;..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common;..\..\..\..\..\components\softdevice\s140\headers;..\..\..\..\..\components\softdevice\s140\headers\nrf52;..\..\..\..\..\components\toolchain;..\..;..\..\..\dfu_req_handling;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0xf0000 size 0x14000
  memory RVCT9: RAM 0x200027e0 size 0x3d7a0
  link misc: --diag_suppress 6330
  group Application
    ../../: main.c
    ../config/: sdk_config.h ethernet_dfu.h
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings_svci.c nrf_dfu_transport.c
    ../../../../../components/libraries/bootloader/TFTP_dfu/: nrf_dfu_tftp.c nrf_dfu_tftp_settings.c nrf_dfu_tftp_utils.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
    ../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/hci/: hci_mem_pool.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/sha256/: sha256.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
  group nRF_SVC
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../../../components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group wiznet
    ../../../../../external/wiznet/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../../../../../external/wiznet/ioLibrary_Driver/Ethernet/: wizchip_conf.c socket.c
    ../../../../../external/wiznet/ioLibrary_Driver/Internet/TFTP/: netutil.c tftp.c
    ../../../../../external/wiznet/: user_ethernet.c
  group nRF_Log
    ../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SEGGER_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
